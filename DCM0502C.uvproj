# Keil uVision project DCM0502C.uvproj, settings and files
target DCM0502C (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: DCM0502C +hex
  AfterMake: hex2bin.exe    ./output/DCM0502C.hex  ./output/DCM0502C.bin
  c flags: Optimize=8 SizeSpeed=1
  c include: .\includes;.\User;.\Library\Includes;.\TS_Lib\Includes
  group User
    ./User/: main.c app_task.c adc_key.c bluetooth_control.c isr.c led_control.c pll_i2c.c RDA5807.c app_config.h
  group Lib
    ./Library/Lib/: STARTUP.A51
    ./Library/Sources/: system_clock.c wdt.c uart.c pwm.c adc.c stop_idle.c delay.c lcd_led.c timer.c exint.c rtc.c
  group ca51f_config
    ./includes/: ca51f_config.h
  group TS_Lib
    ./TS_Lib/Sources/: ts_api.c ts_sevice.c key.c
