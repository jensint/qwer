# Keil uVision project Poweroff_Memory.uvproj, settings and files
target CA51FX (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51fx +hex
  AfterMake: make_bin.bat
  c flags: Optimize=8 SizeSpeed=1
  group ca51f_config
    ./: ca51f_config.h
  group Source Files
    ./: main.c poweroff_memory.c
    ../../Library/Sources/: uart.c flash.c
  group Lib
    ../../Library/Lib/: STARTUP.A51
